<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tcola_m</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tcola_r</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>528</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_2</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>500</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_1_1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/cjam/Documents/gr-tcola/grc/test-file.wav</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/cjam/Documents/colter-thesis/data/recorded_cml_1k_tone.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/cjam/Documents/gr-tcola/grc/test-file.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>tcola_overlap_add</key>
<param><key>id</key><value>tcola_overlap_add_0_0</value></param>
<param><key>hopSize</key><value>tcola_r</value></param>
<param><key>windowSize</key><value>tcola_m</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>tcola_overlap_add</key>
<param><key>id</key><value>tcola_overlap_add_0_0_0</value></param>
<param><key>hopSize</key><value>tcola_r</value></param>
<param><key>windowSize</key><value>tcola_m</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>tcola_time_compression</key>
<param><key>id</key><value>tcola_time_compression_0_0</value></param>
<param><key>hopSize</key><value>tcola_r</value></param>
<param><key>windowSize</key><value>tcola_m</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>tcola_time_compression</key>
<param><key>id</key><value>tcola_time_compression_0_0_0</value></param>
<param><key>hopSize</key><value>tcola_r</value></param>
<param><key>windowSize</key><value>tcola_m</value></param>
<param><key>window</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_2</source_block_id><sink_block_id>tcola_time_compression_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_2</source_block_id><sink_block_id>tcola_time_compression_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>tcola_time_compression_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tcola_overlap_add_0_0</source_block_id><sink_block_id>audio_sink_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tcola_overlap_add_0_0_0</source_block_id><sink_block_id>audio_sink_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tcola_time_compression_0_0</source_block_id><sink_block_id>tcola_overlap_add_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tcola_time_compression_0_0_0</source_block_id><sink_block_id>tcola_overlap_add_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
