<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>four_level_rrc_transmitter</value></param>
<param><key>author</key><value>Colter McQuay</value></param>
<param><key>category</key><value>Colter</value></param>
<param><key>description</key><value>Converts a bit stream into 4 level symbols that are then passed through an RRC filter</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>4 Level RRC Transmitter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>sym_rate*samp_per_sym</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>Filter Alpha</value></param>
<param><key>value</key><value>0.350</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bits_per_symbol</value></param>
<param><key>label</key><value>Bits Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0_0</value></param>
<param><key>k</key><value>bits_per_symbol</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>(1,3,-1,-3)</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>samp_per_sym</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>Impulses</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>pulses</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>Bits</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>samp_per_sym</value></param>
<param><key>interp</key><value>samp_per_sym</value></param>
<param><key>ntaps</key><value>rrc_taps</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>sym_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>label</key><value>Filter Length</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>label</key><value>Samples Per Symbol</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>label</key><value>Symbol Rate</value></param>
<param><key>value</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_pack_k_bits_bb_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>pad_sink_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
