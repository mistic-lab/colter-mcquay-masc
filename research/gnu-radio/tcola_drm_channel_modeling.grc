<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dmr_tcola_cpx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_taps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>np.rand(5)</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_signals</value></param>
<param><key>comment</key><value>Extracts the signal name from configuration file</value></param>
<param><key>config_file</key><value>/home/cjam/Documents/colter-thesis/research/gnu-radio/config.txt</value></param>
<param><key>value</key><value>"signal1,signal2"</value></param>
<param><key>option</key><value>signals</value></param>
<param><key>section</key><value>dmr</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc_dmr</value></param>
<param><key>value</key><value>446106250</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>AWGN Noise Voltage</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>4.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>results_dir</value></param>
<param><key>value</key><value>"/home/cjam/Documents/colter-thesis-results"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>14000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>signal_index</value></param>
<param><key>comment</key><value>0 - 1 KHz Test Tone
1 - Data Message 1 ("DE9945 Data Message using rate 1/2 data")
2 - Data Message 2 ("Hello World from the DE9945")
3 - Voice
4 - Pseudo Random Bit Sequence</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>signal_name</value></param>
<param><key>value</key><value>signal_names[max(0,min(signal_index,len(signal_names)-1))]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>signal_names</value></param>
<param><key>value</key><value>config_signals.split(",")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>standard_suffix</value></param>
<param><key>value</key><value>"_m="+str(tcola_m)+"_r="+str(tcola_r)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tcola_m</value></param>
<param><key>comment</key><value>Window Size</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tcola_m</value></param>
<param><key>comment</key><value>Window Size</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tcola_m</value></param>
<param><key>comment</key><value>Window Size</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tcola_m</value></param>
<param><key>comment</key><value>Window Size - Can only enable one at a time</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tcola_m</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tcola_r</value></param>
<param><key>comment</key><value>Hop Size</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tcola_r</value></param>
<param><key>comment</key><value>Hop Size</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tcola_r</value></param>
<param><key>comment</key><value>Hop Size</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tcola_r</value></param>
<param><key>comment</key><value>Hop Size</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tcola_r</value></param>
<param><key>comment</key><value>Hop Size</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_fs</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_tc_fs</value></param>
<param><key>value</key><value>samp_rate*tcola_m/tcola_r</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>results_dir+"/"+signal_name+"_tc"+standard_suffix+".dat"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>results_dir+"/"+signal_name+"_ola"+standard_suffix+".dat"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>noise_voltage</key><value>noise_gain</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1</value></param>
</block>
<block>
<key>data_sink</key>
<param><key>id</key><value>data_sink_1</value></param>
<param><key>root_dir</key><value>results_dir</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file_ext</key><value>".dat"</value></param>
<param><key>prefix</key><value>""</value></param>
<param><key>suffix</key><value>"_tc"+standard_suffix</value></param>
<param><key>name</key><value>signal_name</value></param>
</block>
<block>
<key>data_sink</key>
<param><key>id</key><value>data_sink_1_0</value></param>
<param><key>root_dir</key><value>results_dir</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file_ext</key><value>".dat"</value></param>
<param><key>prefix</key><value>""</value></param>
<param><key>suffix</key><value>"_tc_rx"+standard_suffix</value></param>
<param><key>name</key><value>signal_name</value></param>
</block>
<block>
<key>data_sink</key>
<param><key>id</key><value>data_sink_1_0_0</value></param>
<param><key>root_dir</key><value>results_dir</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file_ext</key><value>".dat"</value></param>
<param><key>prefix</key><value>""</value></param>
<param><key>suffix</key><value>"_ola"+standard_suffix</value></param>
<param><key>name</key><value>signal_name</value></param>
</block>
<block>
<key>dmr_signal_source_norepeat</key>
<param><key>id</key><value>dmr_signal_source_norepeat_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>root_directory</key><value>"/home/cjam/Documents/colter-thesis/research/data/"</value></param>
<param><key>bandwidth</key><value>14000</value></param>
<param><key>signal_index</key><value>signal_index</value></param>
</block>
<block>
<key>dmr_signal_source_repeat</key>
<param><key>id</key><value>dmr_signal_source_repeat_0</value></param>
<param><key>root_directory</key><value>"/home/cjam/Documents/colter-thesis/research/data/"</value></param>
<param><key>bandwidth</key><value>14000</value></param>
<param><key>signal_index</key><value>signal_index</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>Take our processed DMR Signal
and send it to the DE9945 Board
at the tuned frequency (DMR Channel 1)</value></param>
<param><key>note</key><value>Send to DE9945</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>comment</key><value>Time Compression process increases the
signals sampling rate by M/R</value></param>
<param><key>note</key><value>Time Compression</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0</value></param>
<param><key>comment</key><value>Overlap and Add process decimates the
Time Compressed signal by M/R</value></param>
<param><key>note</key><value>Overlap and Add</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_1</value></param>
<param><key>comment</key><value>Model a channel mathematically</value></param>
<param><key>note</key><value>Channel Modelling</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Message Signal</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>comment</key><value>This section is for saving results of various
steps in the processing pipeline</value></param>
<param><key>note</key><value>Saving Results</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>usrp_tc_fs</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>usrp_tc_fs</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>200000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>tcola_overlap_add</key>
<param><key>id</key><value>tcola_overlap_add_0_0</value></param>
<param><key>hopSize</key><value>tcola_r</value></param>
<param><key>type</key><value>c</value></param>
<param><key>windowSize</key><value>tcola_m</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>tcola_time_compression</key>
<param><key>id</key><value>tcola_time_compression_0</value></param>
<param><key>hopSize</key><value>tcola_r</value></param>
<param><key>type</key><value>c</value></param>
<param><key>windowSize</key><value>tcola_m</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>fc_dmr</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>200000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>tc_rx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>tc_tx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>tc_tx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_0</value></param>
<param><key>stream_id</key><value>message</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>ola_tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>tc_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>tc_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>tc_tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1</value></param>
<param><key>stream_id</key><value>message</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>tc_tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>tc_tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>tc_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_1</value></param>
<param><key>stream_id</key><value>message</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ola_tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ola_tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0_0_0</value></param>
<param><key>stream_id</key><value>ola_tx</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dmr_signal_source_norepeat_0</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dmr_signal_source_repeat_0</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tcola_overlap_add_0_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tcola_time_compression_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>tcola_overlap_add_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>data_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>data_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_1</source_block_id><sink_block_id>tcola_time_compression_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0_0</source_block_id><sink_block_id>data_sink_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
