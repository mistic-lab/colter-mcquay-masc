<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tcola_process_record</value></param>
<param><key>category</key><value>Colter</value></param>
<param><key>description</key><value>Records TCOLA Processing into files</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>TCOLA Record</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>base_file_path</value></param>
<param><key>value</key><value>results_dir+name</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>param_string</value></param>
<param><key>value</key><value>"m="+str(tcola_m)+"_r="+str(tcola_r)</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>base_file_path+"_tc_"+param_string+".dat"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>base_file_path+"_ola.dat"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>name</value></param>
<param><key>label</key><value>Name of signal</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"Signal"</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>results_dir</value></param>
<param><key>label</key><value>Results Directory</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/home/cjam/Documents/colter-thesis/research/results"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tcola_m</value></param>
<param><key>label</key><value>Window Size (M)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>tcola_overlap_add</key>
<param><key>id</key><value>tcola_overlap_add_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hopSize</key><value>tcola_r</value></param>
<param><key>type</key><value>f</value></param>
<param><key>windowSize</key><value>tcola_m</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tcola_r</value></param>
<param><key>label</key><value>Hop Size (R)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>tcola_time_compression</key>
<param><key>id</key><value>tcola_time_compression_0_0</value></param>
<param><key>hopSize</key><value>tcola_r</value></param>
<param><key>type</key><value>f</value></param>
<param><key>windowSize</key><value>tcola_m</value></param>
<param><key>window</key><value></value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>tcola_time_compression_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tcola_overlap_add_0_0</source_block_id><sink_block_id>blocks_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tcola_time_compression_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tcola_time_compression_0_0</source_block_id><sink_block_id>tcola_overlap_add_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
