<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sample_counter</value></param>
<param><key>author</key><value>Colter McQuay</value></param>
<param><key>category</key><value>Colter</value></param>
<param><key>description</key><value>Counts the number of samples that pass through the block.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Sample Counter</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>counter</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class counter(gr.sync_block):
    def __init__(self):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='Sample Counter',
            in_sig=[np.byte],
            out_sig=[np.byte]
        )
        self.count = 0

    def get_count(self):
	return self.count

    def work(self, input_items, output_items):
        output_items[0][:] = input_items[0]
	items_processed = len(output_items[0])
	self.count = self.count + items_processed
        return items_processed
</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>counter</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>counter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
