<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dmr_signal_source_norepeat</value></param>
<param><key>author</key><value>Colter McQuay</value></param>
<param><key>category</key><value>Colter</value></param>
<param><key>description</key><value>Provides DMR Signals for use in other flow graphs.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>DMR Signal Source (No Repeat)</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_signals</value></param>
<param><key>comment</key><value>Extracts the signal name from configuration file</value></param>
<param><key>config_file</key><value>/home/cjam/Documents/colter-thesis/research/gnu-radio/config.txt</value></param>
<param><key>value</key><value>"signal1,signal2"</value></param>
<param><key>option</key><value>signals</value></param>
<param><key>section</key><value>dmr</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>signal_name</value></param>
<param><key>value</key><value>signal_names[min(signal_index,len(signal_names)-1)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>signal_names</value></param>
<param><key>value</key><value>config_signals.split(",")</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>comment</key><value>Bandwidth of DMR signal is 12.5 KHz.
Using 14 KHz to leave some extra room 
in the spectrum.</value></param>
<param><key>label</key><value>Signal Bandwidth</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>14000</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>root_directory+"/"+signal_name+".dat"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>bandwidth</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>root_directory</value></param>
<param><key>comment</key><value>Root Directory of signals</value></param>
<param><key>label</key><value>Root Directory</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/home/cjam/Documents/colter-thesis/research/data/"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>signal_index</value></param>
<param><key>comment</key><value>Signal Index is used to pick a signal out of the
collection of signals</value></param>
<param><key>label</key><value>Signal</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
