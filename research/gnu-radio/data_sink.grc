<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>data_sink</value></param>
<param><key>author</key><value>Colter McQuay</value></param>
<param><key>category</key><value>Colter</value></param>
<param><key>description</key><value>Sinks data into a file</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Data Sink</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>root_dir+"/"+prefix+name+suffix+file_ext</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_ext</value></param>
<param><key>label</key><value>File Extension</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>".dat"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>name</value></param>
<param><key>label</key><value>Name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prefix</value></param>
<param><key>label</key><value>File Prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>root_dir</value></param>
<param><key>label</key><value>Directory</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/home/cjam/Documents/colter-thesis-results"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>suffix</value></param>
<param><key>label</key><value>File Suffix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
