<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>comment</key><value>Bandwidth of DMR signal is 12.5 KHz.
Using 14 KHz to leave some extra room 
in the spectrum.</value></param>
<param><key>value</key><value>14000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>comment</key><value>The carrier Frequency to transmit and receive on.

Based on:

|  DMR446  | Frequency |
|  Channel |   (MHz)   |
| --------------- | ------------- |
|    1     | 446.10625 |
|    2     | 446.11875 |
|    3     | 446.13125 |
|    4     | 446.14375 |
|    5     | 446.15625 |
|    6     | 446.16875 |
|    7     | 446.18125 |
|    8     | 446.19375 |</value></param>
<param><key>value</key><value>446106250</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>root_dir</value></param>
<param><key>comment</key><value>The directory to save and read files to / from.</value></param>
<param><key>value</key><value>"/home/cjam/Documents/colter-thesis/research/data/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>signal_index</value></param>
<param><key>comment</key><value>Signal to use as defined in config.txt file:

0 - 1 KHz Test Tone
1 - Data Message 1 ("DE9945 Data Message using rate 1/2 data")
2 - Data Message 2 ("Hello World from the DE9945")
3 - Voice
4 - Pseudo Random Bit Sequence</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_samp_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>dmr_signal_sink</key>
<param><key>id</key><value>dmr_signal_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>root_directory</key><value>"/home/cjam/Documents/colter-thesis/research/data/"</value></param>
<param><key>bandwidth</key><value>14000</value></param>
<param><key>signal_index</key><value>signal_index</value></param>
</block>
<block>
<key>dmr_signal_source_repeat</key>
<param><key>id</key><value>dmr_signal_source_repeat_0</value></param>
<param><key>root_directory</key><value>"/home/cjam/Documents/colter-thesis/research/data/"</value></param>
<param><key>bandwidth</key><value>14000</value></param>
<param><key>signal_index</key><value>signal_index</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Recording</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>Playback</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>comment</key><value>Only enable recording or playback for any given time.
Playback is just here for convenience of verifying signals.

When recording is enabled use the following setup:

In GNU Radio:
1. Choose signal_index to match desired mode
2. Choose fc to match desired DMR Channel

On DE9945:
1. Select DMR channel (i.e. Dxx) to match fc
2. Press * and select appropriate mode
3. Connect antenna output to attenuator (use at least 30db)
4. Connect attenuator output to USRP rx</value></param>
<param><key>note</key><value>Instructions</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label1</key><value>File</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>usrp_samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>bandwidth</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0</value></param>
<param><key>decim</key><value>bandwidth</value></param>
<param><key>interp</key><value>usrp_samp_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>bandwidth</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>addr=192.168.10.2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>bandwidth</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>dmr_signal_source_repeat_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dmr_signal_source_repeat_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>dmr_signal_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
